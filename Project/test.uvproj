# Keil uVision project test.uvproj, settings and files
target test (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: test +hex
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Devices;..\FWlib\inc;..\System;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Devices
    ../Devices/led/: bsp_led.c
    ../Devices/key/: key1.c
    ../Devices/: common.h
    ../Devices/usart/: bsp_usart.c rx_data_queue.c gnss_usart2.c bc35_usart3.c bc35_queue.c
    ../Devices/bc35g/: BC35.c
    ../Devices/lock/: un_lock.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startup
    ../Startup/: startup_stm32f10x_md.s
  group System
    ../System/delay/: delay.c
    ../System/sys/: sys.c
    ../System/TIM/: TiMbase.c
    ../System/scheduler/: scheduler.c scheduler.h
    ../System/utils/: utils.c
    ../System/ADC/: adc.c adc.h
  group User
    ../User/: main.c stm32f10x_it.c
